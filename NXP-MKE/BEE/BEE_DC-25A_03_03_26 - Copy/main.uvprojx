# Keil uVision project main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKE02Z64xxx4 NXP
  pack: Keil.Kinetis_KExx_DFP.1.8.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: main
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group Source Group 1
    ./: main.c i2c.c i2c.h main.h flash.c flash.h derivative.c ke02_config.h password.c password.h display_support.c display_support.h ftm.c ftm.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.1.0
